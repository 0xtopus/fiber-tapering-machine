# Keil uVision project STemWin.uvprojx, settings and files
target Fiber_tampering (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c misc: --locale=english
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SDRAM;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\EMWIN\Demo;..\DSP_LIB\Include;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\HARDWARE\PWMOUT;..\HARDWARE\MOTORCONTROL;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: ltdc.c tftlcd.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c ft5206.c gt9147.c ott2001a.c gt9271.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/MOTORCONTROL/: motorcontrol.c
    ../HARDWARE/ADC/: adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM7lfsp_math.lib
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: GUI_CM4F_L.lib
  group EMWIN_CONFIG
    ../EMWIN/STemWin/OS/: GUI_X.c
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_Lin_Template.c LCDConf_FlexColor_Template.c
  group EMWIN_DEMO
    ../EMWIN/Demo/: dual_motorDLG.c single_motorDLG.c Window1DLG.c PAGEDLG.c
  group FONTS
    ../EMWIN/Demo/: MenuSong24.c MenuMSBlack24.c FontMenu24.c
target STemWin RGBLCD (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: as above
  output: Template +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SDRAM;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\DSP_LIB\Include;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\EMWIN\Demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
